# Keil uVision project FOC_ADC.uvprojx, settings and files
target FOC_ADC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FOC_ADC +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Hardware/InlineCurrentSense;../Hardware/Usrt;../Hardware/_ReadADC;../Hardware/FOC_Define;../Hardware/delay;../Hardware/CurrentSense;../Hardware/Base_Motor_Control;../Hardware/FOC_Motor;../Hardware/Low_pass_filtering;../Hardware/PID_Motor;../Hardware/AS5600
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Hardware
    ../Hardware/Usrt/: Usrt.c
    ../Hardware/delay/: delay_JR.c
  group Simple FOC
    ../Hardware/InlineCurrentSense/: InlineCurrentSense.c
    ../Hardware/_ReadADC/: Inline_ADC.c
    ../Hardware/FOC_Define/: FOC_Define.c
    ../Hardware/CurrentSense/: CurrentSense.c
    ../Hardware/Base_Motor_Control/: Base_Motor_Control.c
    ../Hardware/FOC_Motor/: FOC_Motor.c
    ../Hardware/Low_pass_filtering/: Low_pass_filtering.c
    ../Hardware/PID_Motor/: PID_Motor.c
    ../Hardware/AS5600/: AS5600.c
software components: CMSIS:CORE 4.3.0
